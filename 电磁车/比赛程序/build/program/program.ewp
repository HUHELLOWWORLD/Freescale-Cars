# IAR project program.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\projects\program; ..\..\src\projects\program\personal; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\projects\fire_pwm_demo; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\build
  group app
    ../../src/projects/program/: isr.c main.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/drivers/adc/: adc.c
    ../../src/common/: common.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/projects/program/: isr.h
    ../../src/platforms/: k60_fire.h
    ../../src/cpu/: vectors.h
  group 头文件
    ../../src/projects/program/: include.h
    ../../src/projects/program/personal/: 信号采集.h 换页.h 无线模块.h 液晶显示.h 赋值.h 速度控制.h 键盘.h
  group 库文件
    ../../src/projects/program/personal/: 信号采集.c 换页.c 无线模块.c 液晶显示.c 赋值.c 速度控制.c 键盘.c
